Commit message: beautified objective_object + some tweaks for training

File: objective_object.urdf (robot description, URDF)
Before this commit: robot objective, 1 links, 0 joints
Links:
- link base_link: geometry visual cylinder length=5 radius=0.02
